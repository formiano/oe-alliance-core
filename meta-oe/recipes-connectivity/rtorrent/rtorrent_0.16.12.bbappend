SRC_URI:remove = "file://0001-configure-add-MIPS-to-the-Linux-cacheline-fallback.patch"
